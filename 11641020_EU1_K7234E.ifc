Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b97efacc-afe2-46ab-9c28-1df0700c3263, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T21:06:53+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11641020_EU1_K7234E:36723400_EU1_11641020_K7234E, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Glass, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1022 mm; Depth: 546 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36723400_EU1_11641020_K7234E; sets with these values: 2

# IfcDistributionPort, Port_353973_1
Description: Flow; FlowDirection: SOURCEANDSINK
